# Keil uVision project template.uvproj, settings and files
target temple (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\app;.\cmsis;.\interrupt;.\library\inc;.\library\src;.\driver;.\ucos\uCOS-II\Ports;.\ucos\uCOS-II\Source;.\ucos\uC-CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/: main.c app_hooks.c
  group driver
    ./driver/: sci.c
  group boot
    ./boot/: startup_stm32f10x_hd.s
  group interrupt
    ./interrupt/: stm32f10x_it.c
  group ucos/ports
    ./ucos/uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm os_dbg.c
  group ucos/cpu
    ./ucos/uC-CPU/: cpu_a.asm
  group ucos/ucos_ii
    ./ucos/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group cmsis
    ./cmsis/: core_cm3.c system_stm32f10x.c
  group library
    ./library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group doc
    ./doc/: readme.txt
